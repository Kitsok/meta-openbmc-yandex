SRC_URI = "https://pypi.python.org/packages/source/I/IPy/IPy-${PV}.tar.gz"

SRC_URI[md5sum] = "7b8c6eb4111b15aea31b67108e769712"
SRC_URI[sha256sum] = "61da5a532b159b387176f6eabf11946e7458b6df8fb8b91ff1d345ca7a6edab8"
